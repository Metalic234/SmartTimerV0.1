<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Stm32f030f4(timer)firmware.ewp</path>
  </project>
  <batchBuild />
</workspace>
